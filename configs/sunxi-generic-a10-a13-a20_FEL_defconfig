## configs/sunxi-generic-a10-a13-a20_FEL_defconfig
```kconfig
CONFIG_SPL=y
CONFIG_SYS_EXTRA_OPTIONS="SUNXI_GENERIC_A10_A13_A20,SPL_FEL"
+S:CONFIG_ARM=y
+S:CONFIG_TARGET_SUN4I_SUN5I_SUN7I=y
```
